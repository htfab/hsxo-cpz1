v {xschem version=3.4.5 file_version=1.2
}
G {}
K {}
V {}
S {}
E {}
C {sky130_ht_ip__hsxo_cpz1.sym} 0 -130 0 0 {name=X1}
C {devices/lab_pin.sym} 60 -30 0 1 {name=p2 sig_type=std_logic lab=AVSS
}
C {devices/lab_pin.sym} -60 -230 0 0 {name=p4 sig_type=std_logic lab=DVDD}
C {devices/lab_pin.sym} 60 -230 0 1 {name=p6 sig_type=std_logic lab=AVDD}
C {devices/lab_pin.sym} 170 -110 0 1 {name=p9 sig_type=std_logic lab=DOUT}
C {devices/lab_pin.sym} -170 -150 0 0 {name=p7 sig_type=std_logic lab=ENA
}
C {devices/lab_pin.sym} -170 -130 0 0 {name=p10 sig_type=std_logic lab=STDBY
}
C {package_model.sym} 0 80 0 0 {name=X2
}
C {devices/lab_pin.sym} -60 -30 0 0 {name=p15 sig_type=std_logic lab=GND}
C {devices/lab_pin.sym} 0 150 0 0 {name=p16 sig_type=std_logic lab=GND}
C {devices/lab_pin.sym} 170 -90 0 1 {name=p18 sig_type=std_logic lab=XOUTPAD}
C {devices/lab_pin.sym} -170 -90 0 0 {name=p19 sig_type=std_logic lab=XINPAD}
C {devices/lab_pin.sym} -150 50 0 0 {name=p1 sig_type=std_logic lab=XINPAD}
C {devices/lab_pin.sym} -150 80 0 0 {name=p20 sig_type=std_logic lab=XOUTPAD}
C {devices/lab_pin.sym} -150 110 0 0 {name=p21 sig_type=std_logic lab=AVSS
}
C {devices/lab_pin.sym} 150 50 0 1 {name=p22 sig_type=std_logic lab=XIN}
C {devices/lab_pin.sym} 150 80 0 1 {name=p24 sig_type=std_logic lab=XOUT}
C {devices/lab_pin.sym} 150 110 0 1 {name=p25 sig_type=std_logic lab=GND}
C {devices/lab_pin.sym} -170 -190 0 0 {name=p3 sig_type=std_logic lab=IBIAS
}
C {devices/iopin.sym} -370 -200 0 0 {name=p32 lab=DVDD}
C {devices/iopin.sym} -370 -140 0 0 {name=p33 lab=GND
}
C {devices/iopin.sym} -370 -170 0 0 {name=p34 lab=AVDD}
C {devices/ipin.sym} -300 -60 0 0 {name=p36 lab=ENA}
C {devices/ipin.sym} -300 -30 0 0 {name=p37 lab=STDBY}
C {devices/ipin.sym} -300 20 0 0 {name=p38 lab=XIN}
C {devices/opin.sym} -370 50 0 0 {name=p39 lab=XOUT}
C {devices/opin.sym} -370 80 0 0 {name=p40 lab=DOUT}
C {devices/ipin.sym} -300 -90 0 0 {name=p41 lab=IBIAS}
